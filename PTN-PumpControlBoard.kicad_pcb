# Repository lhr-solar/PTN-PumpControlBoard

## KiCad design PTN-PumpControlBoard.kicad_pcb

Parts:
C1, C2: 1uF; C_0805_2012Metric
J1: PeripheralCANConnector; Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical
R1, R2, R3: 10k; R_0805_2012Metric
R4: 15k; R_0805_2012Metric
U1: EMC2305-1-AP-TR; QFN16_4x4MC_MCH
U2: PeripheralSOM
U3: ST7735R; adafruit_st7735r

Connections:
+3.3V: C1.1, C2.1, R1.2, R2.2, R3.2, R4.2, U1.3 (VDD), U2.2 (+3.3V), U2.9 (+3.3V), U3.2 (VCC), U3.4 (DC); also elsewhere on the board
+12V: J1.1 (12V), U2.22 (+12V_In); also elsewhere on the board
/FAN1_PWM: R3.1, U1.5 (PWM1); also elsewhere on the board
/FAN1_TACH: U1.6 (TACH1); also elsewhere on the board
/FAN2_PWM: R2.1, U1.7 (PWM2); also elsewhere on the board
/FAN2_TACH: U1.8 (TACH2); also elsewhere on the board
/FAN_SCL: U1.1 (SMDATA), U2.8 (I2C2_SCL)
/FAN_SDA: U1.2 (SMCLK), U2.6 (I2C2_SDA)
/FAN_SPEED: U2.3 (SPI2_MISO); also elsewhere on the board
/FLOW: U2.1 (SPI2_MOSI); also elsewhere on the board
/LCD_RESET: U2.15 (SPI1_MISO), U3.3 (Reset)
/LCD_TFT_~CS: U2.19 (SPI1_NSS), U3.6 (TFT_CS)
/MOSI: U2.17 (SPI1_MOSI), U3.7 (MOSI)
/PUMP_PG: U2.14 (I2C1_SCL); also elsewhere on the board
/PUMP_PWM: U2.16 (I2C1_SDA); also elsewhere on the board
/PUMP_SPEED: U2.5 (SPI2_SCK); also elsewhere on the board
/SCLK: U2.13 (SPI1_SCK), U3.8 (SCK)
/SYST_MODE: U2.7 (SPI2_NSS); also elsewhere on the board
/TEMP1: U2.18 (PA2(ADC)); also elsewhere on the board
/TEMP2: U2.20 (PA1(ADC)); also elsewhere on the board
/~SMBALERT: R1.1, U1.12 (*ALERT)
AGND: U2.12 (GNDA)
CAN_H: J1.3 (CAN_H), U2.23 (CAN_H)
CAN_L: J1.4 (CAN_L), U2.21 (CAN_L)
GND: C1.2, C2.2, U1.HTAB (EPAD), U2.4 (GND), U2.11 (GND), U3.1 (GND), U3.10 (LITE); also elsewhere on the board
GNDPWR: J1.2 (GNDPWR), U2.24 (GNDPWR)
unnamed: R4.1, U1.11 (CLK)
VDDA: U2.10 (VDDA(3.3V))

Notes on the sheet:
PERIPHERAL SOM
POWER IN
ADDITIONAL SHEETS
LCD DISPLAY
FAN CONTROL IC
can this be a gpio?
???

Parts:
R17, R18: 1k; R_0805_2012Metric
TEMP1, TEMP2: Conn_01x02; Molex_MicroFit3.0_1x2xP3.00mm_PolarizingPeg_Vertical

Connections:
+3.3V: R17.1; also elsewhere on the board
+3V3: R18.1
/TEMP1: R17.2, TEMP1.2; also elsewhere on the board
/TEMP2: R18.2, TEMP2.2; also elsewhere on the board
GND: TEMP1.1, TEMP2.1; also elsewhere on the board

Notes on the sheet:
THERMISTOR VALUES: R at min temp: 12k (20C/68F) -> TEMP_SEN1 = 3.06V R at max temp: 1.2k (90C/194F) -> TEMP_SEN1 = 0.39V

Parts:
C3, C4, C5: 0.1uF; C_0805_2012Metric
R11, R12, R13: 1k; R_0805_2012Metric
R14, R15, R16: 10k; R_0805_2012Metric
SW1: SW_Push; TL3305BF160QG; Mouser# TL3305AF160QG
SW2, SW3: SW_Push; TL3305BF160QG

Connections:
+3.3V: SW1.2, SW2.2, SW3.2; also elsewhere on the board
/FAN_SPEED: C3.2, R11.2; also elsewhere on the board
/PUMP_SPEED: C4.2, R12.2; also elsewhere on the board
/SYST_MODE: C5.2, R13.2; also elsewhere on the board
GND: C3.1, C4.1, C5.1, R14.2, R15.2, R16.2; also elsewhere on the board
unnamed: R11.1, R14.1, SW1.1
unnamed: R12.1, R15.1, SW2.1
unnamed: R13.1, R16.1, SW3.1

Parts:
J8: Conn_01x04; Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical

Parts:
FLOW1: Conn_01x03; Molex_MicroFit3.0_1x3xP3.00mm_PolarizingPeg_Vertical
Q3: NMOS; LFPAK33
R19, R20: 10k; R_0805_2012Metric

Connections:
+3.3V: Q3.1 (D); also elsewhere on the board
+12V: FLOW1.2; also elsewhere on the board
/FLOW: Q3.3 (S), R19.2, R20.1; also elsewhere on the board
/FlowrateSensor/FLOW_OUT: FLOW1.1, Q3.2 (G), R19.1
GND: FLOW1.3, R20.2; also elsewhere on the board

Parts:
D1, D2: 1N4448W; D_SOD-323
FAN1, FAN2: Conn_01x03; Molex_MicroFit3.0_1x3xP3.00mm_PolarizingPeg_Vertical
Q1, Q2: NMOS; LFPAK33
R5, R8: 1k; R_0805_2012Metric
R6, R9: 380; R_0805_2012Metric
R7, R10: 10k; R_0805_2012Metric

Connections:
+12V: D1.1 (K), D2.1 (K), FAN1.1, FAN2.1; also elsewhere on the board
/FAN1_PWM: Q1.2 (G), R7.1; also elsewhere on the board
/FAN1_TACH: R5.2, R6.1; also elsewhere on the board
/FAN2_PWM: Q2.2 (G), R10.1; also elsewhere on the board
/FAN2_TACH: R8.2, R9.1; also elsewhere on the board
/Fans/TACH1_IN: FAN1.2, R5.1
/Fans/TACH2_IN: FAN2.2, R8.1
GND: Q1.3 (S), Q2.3 (S), R6.2, R7.2, R9.2, R10.2; also elsewhere on the board
unnamed: D1.2 (A), FAN1.3, Q1.1 (D)
unnamed: D2.2 (A), FAN2.3, Q2.1 (D)

Notes on the sheet:
FAN 2
FAN 1

Board: 2 copper layers, 100.2 x 72.0 mm, 43 parts (0 on the bottom side), 34 nets.

Other parts of the board:
PUMP1: Conn_01x04; Molex_MicroFit3.0_1x4xP3.00mm_PolarizingPeg_Vertical

Their connections:
+12V: PUMP1.3; also elsewhere on the board
/PUMP_PG: PUMP1.1; also elsewhere on the board
/PUMP_PWM: PUMP1.2; also elsewhere on the board
GND: PUMP1.4; also elsewhere on the board

## Commit log

2025-03-01 connectors
2025-03-10 testing
2025-04-02 Added pull up resistors for open drain configs
2025-04-16 Initial schematic design with 2 temp, 1 flow, 1 pump
